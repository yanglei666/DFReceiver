# Keil uVision project DogfenceReceiver.uvproj, settings and files
target Application (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: DogfenceReceiver +hex
  c flags: Optimize=8 SizeSpeed=1
  group Driver
    ./: STARTUP.A51 Common.c Common.h EEPROM.c EEPROM.h Timer.c Timer.h Uart1.c Uart1.h PCA.c PCA.h ADC.c ADC.h LVDF.c LVDF.h
  group User
    ./: main.c
